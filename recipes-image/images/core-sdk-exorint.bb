DESCRIPTION = "Exor International SDK"

require meta-toolchain-qt.inc

inherit populate_sdk

TOOLCHAIN_OUTPUTNAME = "exor-sdk"
