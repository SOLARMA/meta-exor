# Multitouch event handler fix

FILESEXTRAPATHS := "${THISDIR}/files"

SRC_URI += "file://multitouch.patch"
