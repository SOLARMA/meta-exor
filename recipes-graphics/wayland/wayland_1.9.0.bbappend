# iMX6 wayland and hardware acceleration dependencies
RDEPENDS_${PN}_usom03 = "libvivante-mx6 \
		libwayland-viv-mx6 \
                libgc-wayland-protocol-mx6 \
		libgles-mx6 libgles2-mx6"
