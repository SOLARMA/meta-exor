FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://cairo-egl-device-create-for-egl-surface.patch"

