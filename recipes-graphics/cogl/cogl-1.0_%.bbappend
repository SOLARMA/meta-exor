EDEPENDS_WAYLAND_usom01 = "wayland virtual/egl"
