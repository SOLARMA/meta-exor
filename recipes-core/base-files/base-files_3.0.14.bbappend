# Set board hostname
hostname_usom01 = "exorUS01kit"
hostname_usom02 = "exoralterakit"
