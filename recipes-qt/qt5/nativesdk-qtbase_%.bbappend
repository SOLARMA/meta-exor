# Avoid RPM conflicts with cmake
DIRFILES = " "
