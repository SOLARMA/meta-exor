# Add gstreamer support
PACKAGECONFIG += "gstreamer"
